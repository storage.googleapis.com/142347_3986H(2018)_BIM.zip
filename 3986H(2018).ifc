Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-07-18T12:23:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jul 18 12:23:40 2019 * Host: DESKTOP-23GQEAI * Database: C:\Users\vladb\AppData\Local\Temp\{05951C98-8629-47F5-8EE9-13F26CC8F82D}\ifc * Database version: 5507 * Database creation date: Thu Jul 18 12:23:39 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jul 18 12:23:39 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jul 18 12:23:39 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 3986H Cover part for bath and shower faucet, 3986H:3986H Cover part for bath and shower faucet:339036
In: Level 1
Type - PredefinedType: FAUCET
Type - Dimensions - NominalDepth: 91.0114 mm; NominalHeight: 169.706 mm; NominalWidth: 110 mm
Type - General - Author: Convergo AB; BIMObjectName: 3986H(2018); ConvergoRefNr: 0087-1909-0037-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_20_97_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 17/07/2019
Type - Green Building Properties - Customs Code: 84819000; EAN Number: 6414150089183; EN Standard: EN 817; Noise Class: II(ISO 3822)
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/3986H; Catalog Drawing URL: http://static.oras.com/catdrw/3986H; Class: Single lever, Trim Kit; Dimension Drawing URL: http://static.oras.com/dimdrw/3986H; FDV Document URL: http://www.oras.com/datasheet/3986H/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/3986H; Group: Bath and shower faucets; Long Marketing: Oras Saga Style concealed shower faucet, cover part for installation unit 2327, rectangular 130/90mm There are also in-built limitation options for water temperature and maximum flow-rate.; Manufacturer: Oras; Market: RUS; Model: 3986H Cover part for bath and shower faucet; Name_en: 3986H Cover part for bath and shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 210 x 165 x 60; Package Weight: 0.75 kg; Product Code: 3986H; Product Datasheet: http://www.oras.com/datasheet/3986H/en; Product Family: Oras Saga Style; Product Image URL: http://static.oras.com/image/3986H; Product URL: http://static.oras.com/3986H; Type Name: 3986H Cover part for bath and shower faucet
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Flow Rate At 300kPa: 0.0113007 m3/s; Installation and Maintenance: http://static.oras.com/manual/3986H; Installation Type: Wall mounted for concealed unit; Lever Handle: Single Operating Lever; Max. Hot Water Supply: 80 kg/K/s3; Spare Parts: http://static.oras.com/sp/3986H
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 3986H; Features: Single lever, Trim Kit; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 3986H; Name: 3986H Cover part for bath and shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 110x90x170 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 3986H; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 3986H Cover part for bath and shower faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.0441241 m2; Volume: 0.00169897 m3
Identity Data - Mark: 11
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 3986H: 3986H Cover part for bath and shower faucet; Family and Type: 3986H: 3986H Cover part for bath and shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 3986H: 3986H Cover part for bath and shower faucet; Type Id: 3986H: 3986H Cover part for bath and shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
